options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dectrx
    output_language: python
  states: {}

blocks:
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: dect_freq
  id: variable_qtgui_chooser
  parameters:
    label: Carrier Number
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9"]'
    num_opts: '0'
    options: '[1897344000, 1881792000, 1883520000, 1881792000, 1886876000, 1888704000, 1890432000, 1892160000, 1893888000, 1895616000,]'
    type: real
    value: '1897344000'
  states: {state: disabled}
- name: dect_rate
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: dect_ule_freq
  id: variable_qtgui_chooser
  parameters:
    label: Dect ULE Channel
    labels: '["0", "1893,888", "1883,52", ]'
    num_opts: '0'
    options: '[0, 1893888000, 1883520000, ]'
    type: real
    value: '0'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 1897.344e6-(range_channel*1.728e6)
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: range_bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: bb_gain
  states: {}
- name: range_channel
  id: variable_qtgui_range
  parameters:
    label: Channel
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '9'
    value: '5'
  states: {}
- name: range_if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: if_gain
  states: {}
- name: range_ppm
  id: variable_qtgui_range
  parameters:
    label: PPM
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '70'
    value: ppm
  states: {}
- name: range_rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: rf_gain
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/abrenn/filesink.cf32
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2323'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: dect_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    bw0: dect_rate
    corr0: ppm
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: After filter
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_udp_sink_0, '0']
- [digital_gmsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
