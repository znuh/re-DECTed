options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dect_multirx_310
    output_language: python
  states: {}

blocks:
- name: atten
  id: variable
  parameters:
    value: '60'
  states: {}
- name: bb_freq
  id: variable
  parameters:
    value: 1897.344e6-(5*1.728e6)
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: ch_bw
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: ch_tb
  id: variable
  parameters:
    value: 1.728e6-symbol_rate
  states: {}
- name: channels
  id: variable
  parameters:
    value: '11'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, ch_bw, ch_tb, atten, window.WIN_HANN)
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: range_bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: bb_gain
  states: {}
- name: range_if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: if_gain
  states: {}
- name: range_ppm
  id: variable_qtgui_range
  parameters:
    label: PPM
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '70'
    value: ppm
  states: {}
- name: range_rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: rf_gain
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: total_bw
  id: variable
  parameters:
    value: ch_bw*channels
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_udp_sink_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2323'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2324'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2325'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_0_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2328'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_0_0_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2332'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_0_1
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2329'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_1
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2327'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_0_1_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2331'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_1
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2326'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: blocks_udp_sink_0_1_0
  id: network_udp_sink
  parameters:
    send_eof: 'True'
    addr: 127.0.0.1
    port: '2330'
    payloadsize: '1472'
    type: byte
    header: '0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_0_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_0_1
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_1
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0_1_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_1
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_1_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    bw0: 20e6
    corr0: ppm
    freq0: bb_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: '11'
    osr: '1.0'
    taps: pfb_taps
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    interp: '594'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_udp_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_udp_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_udp_sink_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0_0, '0', blocks_udp_sink_0_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1, '0', blocks_udp_sink_0_0_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', blocks_udp_sink_0_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_1_0, '0', blocks_udp_sink_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0_1, '0', blocks_udp_sink_0_1, '0']
- [blocks_pack_k_bits_bb_0_1_0, '0', blocks_udp_sink_0_1_0, '0']
- [digital_gmsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gmsk_demod_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_gmsk_demod_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [digital_gmsk_demod_0_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [digital_gmsk_demod_0_0_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0_0, '0']
- [digital_gmsk_demod_0_0_0_1, '0', blocks_pack_k_bits_bb_0_0_0_1, '0']
- [digital_gmsk_demod_0_0_1, '0', blocks_pack_k_bits_bb_0_0_1, '0']
- [digital_gmsk_demod_0_0_1_0, '0', blocks_pack_k_bits_bb_0_0_1_0, '0']
- [digital_gmsk_demod_0_1, '0', blocks_pack_k_bits_bb_0_1, '0']
- [digital_gmsk_demod_0_1_0, '0', blocks_pack_k_bits_bb_0_1_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', rational_resampler_xxx_1, '0']
- [pfb_channelizer_ccf_0, '10', rational_resampler_xxx_1_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '2', rational_resampler_xxx_1_0, '0']
- [pfb_channelizer_ccf_0, '3', rational_resampler_xxx_1_0_0, '0']
- [pfb_channelizer_ccf_0, '4', rational_resampler_xxx_1_1, '0']
- [pfb_channelizer_ccf_0, '5', rational_resampler_xxx_1_0_1, '0']
- [pfb_channelizer_ccf_0, '6', rational_resampler_xxx_1_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', rational_resampler_xxx_1_0_0_1, '0']
- [pfb_channelizer_ccf_0, '8', rational_resampler_xxx_1_1_0, '0']
- [pfb_channelizer_ccf_0, '9', rational_resampler_xxx_1_0_1_0, '0']
- [rational_resampler_xxx_0, '0', pfb_channelizer_ccf_0, '0']
- [rational_resampler_xxx_1, '0', digital_gmsk_demod_0, '0']
- [rational_resampler_xxx_1_0, '0', digital_gmsk_demod_0_0, '0']
- [rational_resampler_xxx_1_0_0, '0', digital_gmsk_demod_0_0_0, '0']
- [rational_resampler_xxx_1_0_0_0, '0', digital_gmsk_demod_0_0_0_0, '0']
- [rational_resampler_xxx_1_0_0_0_0, '0', digital_gmsk_demod_0_0_0_0_0, '0']
- [rational_resampler_xxx_1_0_0_1, '0', digital_gmsk_demod_0_0_0_1, '0']
- [rational_resampler_xxx_1_0_1, '0', digital_gmsk_demod_0_0_1, '0']
- [rational_resampler_xxx_1_0_1_0, '0', digital_gmsk_demod_0_0_1_0, '0']
- [rational_resampler_xxx_1_1, '0', digital_gmsk_demod_0_1, '0']
- [rational_resampler_xxx_1_1_0, '0', digital_gmsk_demod_0_1_0, '0']

metadata:
  file_format: 1
